# Keil uVision project YongMengOilSenser.uvproj, settings and files
target YongMengOilSenserProgram (ARM-ADS)
  device: M054LBN Nuvoton
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0-0x3FFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: YongMengOilSenser +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 OneElfS=1
  c include: ..\Library\CMSIS\Include;..\Library\Device\Nuvoton\M051Series\Include;..\Library\M051-LB_004\inc;..\Library\StdDriver\inc
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --map --first='startup_M051Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ./: startup_M051Series.s
    ../Library/Device/Nuvoton/M051Series/Source/: system_M051Series.c
  group Library
    ../Library/StdDriver/src/: adc.c gpio.c pwm.c retarget.c timer.c uart.c wdt.c wwdt.c sys.c clk.c acmp.c
  group User
    ../User/: main.c
