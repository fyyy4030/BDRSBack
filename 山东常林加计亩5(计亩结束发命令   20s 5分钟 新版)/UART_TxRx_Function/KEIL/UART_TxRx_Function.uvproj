# Keil uVision project UART_TxRx_Function.uvproj, settings and files
target UART_TxRx_Function (ARM-ADS)
  device: NUC131SD2AE Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: UART_TxRxFunction +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 wLevel=2
  c include: ..\Library\CMSIS\Include;..\Library\Device\Nuvoton\NUC131\Include;..\Library\StdDriver\inc;..\user
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_NUC131.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../Library/Device/Nuvoton/NUC131/Source/ARM/: startup_NUC131.s
    ../Library/Device/Nuvoton/NUC131/Source/: system_NUC131.c
  group User
    ../user/: main.c
  group LIBRARY
    ../Library/StdDriver/src/: uart.c sys.c clk.c gpio.c timer.c can.c adc.c fmc.c wdt.c
  group 说明
    ./: 说明.txt
